直线轴承滑块侧盖 v1 (Autodesk Fusion 360 design; units mm, degrees)
base_feature "基础特征"
fillet "圆角" radius 0.75